Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.003_SECADOR_MÃOS_SENSORIZADO_MEDI_PAREDE.IFC
Time: 2023-12-12T16:57:47
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 70.003_SECADOR_MÃOS_SENSORIZADO_MEDI_PAREDE.sat[2]
In: Default Storey
PSet_Mass_Property - Mass Measure: 41.9151; Area Measure: 0.562044 m2; Volume Measure: 0.00523938 m3
